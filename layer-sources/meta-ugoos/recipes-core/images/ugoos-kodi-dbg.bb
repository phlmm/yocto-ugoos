DESCRIPTION = "A SD/MMC Image for Amlogic Meson SoCs with embedded kernel on the filesystem"
require ugoos-kodi.bb
